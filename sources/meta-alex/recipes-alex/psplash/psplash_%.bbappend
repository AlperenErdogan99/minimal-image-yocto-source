FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SPLASH_IMAGES_rpi = "file://alex-img.h;outsuffix=raspberrypi"
INITSCRIPT_PARAMS = "start 60 S . stop 20 0 1 6 ."
